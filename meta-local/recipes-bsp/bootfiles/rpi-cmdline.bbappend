# The U-Boot RAUC script appends the slot-specific root device.
CMDLINE_ROOTFS = "rootfstype=ext4 rootwait"
